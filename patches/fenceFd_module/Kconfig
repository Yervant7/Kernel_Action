## patches/fenceFd_module/Kconfig
```kconfig
config FENCEFDMOD
	tristate "fenceFd module support"
	default m
	help
	  Enable module fenceFd
	  
```
